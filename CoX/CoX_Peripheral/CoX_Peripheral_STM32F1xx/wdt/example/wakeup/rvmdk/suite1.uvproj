# Keil uVision project suite1.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WdtExample +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1
  c define: rvmdk
  c include: ..\..\..\..\libcox;..\src;
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../startup/src/: startup_rvmdk.s
  group libcox
    ../../../../libcox/: xcore.c xcore.h xdebug.c xdebug.h xgpio.c xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_sysctl.h xhw_types.h xhw_uart.h xsysctl.c xsysctl.h xuart.c xuart.h xhw_rtc.h xwdt.h xhw_wdt.h xwdt.c
  group source
    ../src/: Wakeup.c main.c
target Debug_Ram (ARM-ADS)
  device: NUC140LE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1
  c include: ..\..\..\..\libcox;..\src;..\..\..\..\testframe
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
